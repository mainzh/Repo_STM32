# Keil uVision project Project.uvprojx, settings and files
target Template (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\Libraries\CMSIS\CoreSupport;..\Libraries\CMSIS\DeviceSupport;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\User\Hardware;..\User\System;..\User;..\User\System\Delay;..\User\Software\PID;..\User\Hardware\OLED\OLED_I2C;..\User\Hardware\LED;..\User\Hardware\Key;..\User\Hardware\Buzzer;..\User\Hardware\LightSensor;..\User\System\EXTI;..\User\System\TIM;..\User\Hardware\TimerEX;..\User\Hardware\Servo;..\User\Hardware\Motor;..\User\Hardware\ADC;..\User\System\DMA;..\User\Hardware\Serial;..\User\Hardware\MPU6050\MPU6050_Hardtware;..\User\Hardware\MPU6050\MPU6050_Software;..\User\Hardware\W25Q64\W25Q64_Software;..\User\Hardware\W25Q64\W25Q64_Hardware;..\User\System\RTC;..\User\System\FLASH;..\User\Hardware\PWMO;..\User\Hardware\Encoder
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Libraries\CMSIS\CoreSupport
    ../Libraries/CMSIS/CoreSupport/: core_cm3.c
  group Libraries\CMSIS\DeviceSupport\startup
    ../Libraries/CMSIS/DeviceSupport/startup/: startup_stm32f10x_md.s
  group Libraries\CMSIS\DeviceSupport
    ../Libraries/CMSIS/DeviceSupport/: system_stm32f10x.c
  group Libraries\STM32F10x_StdPeriph_Driver\src
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group User
    ../User/: main.c readme.txt stm32f10x_conf.h stm32f10x_it.c
  group User\Hardware
    ../User/Hardware/OLED/OLED_I2C/: OLED.c
    ../User/Hardware/LED/: LED.c
    ../User/Hardware/Key/: Key.c
    ../User/Hardware/Buzzer/: Buzzer.c
    ../User/Hardware/LightSensor/: LightSensor.c
    ../User/Hardware/Servo/: Servo.c
    ../User/Hardware/Motor/: BDCMotor.c
    ../User/Hardware/CountSensor/: CountSensor.c
    ../User/Hardware/PWMI/: IC.c
    ../User/Hardware/PWMO/: PWM.c
    ../User/Hardware/TimerEX/: TimerEX.c
    ../User/Hardware/Encoder/: EncoderCount.c EncoderSpeed.c
    ../User/Hardware/ADC/: AD.c
    ../User/Hardware/MPU6050/MPU6050_Hardtware/: MPU6050_H.c
    ../User/Hardware/MPU6050/MPU6050_Software/: MPU6050_S.c MyI2C.c
    ../User/Hardware/W25Q64/W25Q64_Software/: W25Q64_S.c MySPI_S.c
    ../User/Hardware/W25Q64/W25Q64_Hardware/: W25Q64_H.c MySPI_H.c
    ../User/Hardware/Serial/: Serial.c
  group User\Software
    ../User/Software/PID/: PID.c
  group User\System
    ../User/System/Delay/: Delay.c
    ../User/System/TIM/: Timer.c
    ../User/System/DMA/: MyDMA.c
    ../User/System/RTC/: MyRTC.c
    ../User/System/: PWR.c IWDG.c WWDG.c
    ../User/System/FLASH/: MyFLASH.c Store.c
